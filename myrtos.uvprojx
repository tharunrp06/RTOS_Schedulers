# Keil uVision project myrtos.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myrtos
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Chip Headers\Include;..\Chip Headers\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Src
    ./: main.c oskernel.c
  group Inc
    ./: oskernel.h
    ../Chip Headers/Device/ST/STM32F4xx/Include/: stm32f401xc.h
  group Startup
    ../Chip Headers/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Chip Headers/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s
software components: CMSIS:CORE 6.1.0
